# Keil uVision project pixyflash.uvprojx, settings and files
target pixyflash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: pixyflash +hex
  AfterMake: fromelf --bin -o "@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CORE_M4 PIXY
  c include: ., ..\libpixy_m4\inc, ..\common\inc, ..\..\common\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ram.sct
  group source
    ./: main.cpp lpc43xx_rgu.c flashprog.cpp
  group libs
    ../libpixy_m4/: libpixy_m4.lib
software components: CMSIS:CORE 5.4.0
