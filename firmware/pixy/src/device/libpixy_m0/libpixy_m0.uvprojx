# Keil uVision project libpixy_m0.uvprojx, settings and files
target libpixy_m0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: libpixy_m0 (library)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: CORE_M0  IPC_SLAVE PIXY KEIL
  c include: ., ..\..\common\inc, ..\common\inc, inc
  asm define: NO_CRP  IPC_SLAVE
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Code
    ./src/: chirp.c debug.c exec_m0.c frame_m0.c rls_m0.c smlink.c qqueue.c
    ../common/src/: debug_frmwrk.c ipc_mbx.c lpc43xx_uart.c
software components: CMSIS:CORE 5.4.0
