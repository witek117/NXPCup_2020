# Keil uVision project libpixy_m4.uvprojx, settings and files
target libpixy_m4 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: libpixy_m4 (library)
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1
  c define: CORE_M4 IPC_MASTER PIXY KEIL
  c include: ., ..\..\common\inc, ..\common\inc, inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Code
    ./src/: camera.cpp flash.cpp fpu_init.c led.cpp misc.cpp param.cpp pixy_init.cpp platform_config.c power.cpp rcservo.cpp sccb.cpp smlink.cpp startup_LPC43xx_m4.s usbcore.c usbdesc.c usbhw.c usblink.cpp usbuser.c spifilib_dev_common.c spifilib_fam_standard_cmd.c exec.cpp
    ../common/src/: debug_frmwrk.c ipc_mbx.c lpc43xx_adc.c lpc43xx_cgu.c lpc43xx_i2c.c lpc43xx_scu.c lpc43xx_ssp.c lpc43xx_uart.c system_LPC43xx.c lpc43xx_timer.c
    ../../common/src/: calc.cpp chirp.cpp
  group libs
    ./: spifi_drv_M4.lib
software components: CMSIS:CORE 5.4.0
